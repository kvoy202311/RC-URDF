Commit message: fix calf mass

File: RCV3/urdf/RCV3.urdf (robot description, URDF)
Before this commit: robot RCA3, 17 links, 16 joints
Links:
- link FL_calf: mass 0.09 -> 0.15
- link FR_calf: mass 0.09 -> 0.15
- link RL_calf: mass 0.09 -> 0.15
- link RR_calf: mass 0.09 -> 0.15
